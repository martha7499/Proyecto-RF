V1 1 0 5
R1 1 2 10
C1 2 0 159E-12
L1 2 0 100E-9
V2 2 0 5
