V1 1 0 5
C1 1 0 1e-12
L1 1 2 1e-9
C2 2 0 1e-12
V2 2 0 6
