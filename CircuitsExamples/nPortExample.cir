L1  1 2 10E-6
L2  2 3 10E-6
L3  3 4 10E-6
L4  4 1 10E-6
C1  1 0 300E-12
C2  2 0 300E-12
C3  3 0 300E-12
C4  4 0 300E-12
V1  1 0 5
V2  2 0 5
V3  3 0 5
V4  4 0 5
