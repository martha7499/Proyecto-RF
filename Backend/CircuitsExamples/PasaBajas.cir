V1 1 0 5
R1 1 2 14
C1 2 0 1300E-12
R2 2 3 25
C2 3 0 470E-12
V2 3 0 5
