R1 1 2 100
R2 2 3 150
R3 3 4 200
L1 1 3 10nH
L2 2 4 20nH
C1 1 4 5pF
C2 2 3 10pF
V1 1 0 DC 10V
V2 2 0 DC 5V
I1 3 4 DC 2A
I2 1 3 DC 1A
